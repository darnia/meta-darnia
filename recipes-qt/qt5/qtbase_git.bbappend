PACKAGECONFIG_append = " accessibility udev eglfs kms gbm fontconfig freetype gles2 linuxfb tslib"
PACKAGECONFIG_remove = "examples tests x11"
